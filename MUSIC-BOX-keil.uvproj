# Keil uVision project MUSIC-BOX-keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MUSIC-BOX-keil +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DAC0832.c delay.c EEPROM.c OLED.c Settings.c song.c switch.c Timer.c LED.c main.c music.c
